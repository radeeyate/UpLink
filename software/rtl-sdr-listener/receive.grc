options:
  parameters:
    generate_options: qt_gui
    id: loratest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: lora_lora_receiver_0
  id: lora_lora_receiver
  parameters:
    bandwidth: '125000'
    center_freq: '915'
    channel_list: '[915e6]'
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '1'
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: 1e6
    sf: '9'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 915e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {}

connections:
- [lora_lora_receiver_0, frames, blocks_message_debug_0, print]
- [lora_lora_receiver_0, frames, zeromq_pub_msg_sink_0, in]
- [rtlsdr_source_0, '0', lora_lora_receiver_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
